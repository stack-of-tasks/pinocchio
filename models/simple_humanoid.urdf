Commit message: [models] Add a geometry in simple_humanoid.urdf

File: models/simple_humanoid.urdf (robot description, URDF)
Before this commit: robot simple_humanoid, 30 links, 29 joints
Links:
- link WAIST_LINK0: geometry collision cylinder length=1 radius=1
